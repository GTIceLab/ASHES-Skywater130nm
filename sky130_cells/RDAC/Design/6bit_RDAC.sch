v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 810 -1060 870 -1060 {
lab=#net1}
N 810 -1040 870 -1040 {
lab=#net2}
N 810 -1020 870 -1020 {
lab=#net3}
N 810 -1000 870 -1000 {
lab=#net4}
N 810 -980 870 -980 {
lab=#net5}
N 810 -960 870 -960 {
lab=#net6}
N 870 -1200 870 -1140 {
lab=#net7}
N 870 -1200 950 -1200 {
lab=#net7}
N 890 -1180 950 -1180 {
lab=#net8}
N 890 -1180 890 -1120 {
lab=#net8}
N 870 -1120 890 -1120 {
lab=#net8}
N 870 -1100 910 -1100 {
lab=#net9}
N 910 -1160 910 -1100 {
lab=#net9}
N 910 -1160 950 -1160 {
lab=#net9}
N 870 -1080 930 -1080 {
lab=#net10}
N 930 -1140 930 -1080 {
lab=#net10}
N 930 -1140 950 -1140 {
lab=#net10}
N 870 -1060 950 -1060 {
lab=#net1}
N 870 -1040 950 -1040 {
lab=#net2}
N 870 -1020 950 -1020 {
lab=#net3}
N 870 -1000 950 -1000 {
lab=#net4}
N 870 -980 950 -980 {
lab=#net5}
N 950 -980 950 -940 {
lab=#net5}
N 870 -960 940 -960 {
lab=#net6}
N 940 -960 940 -920 {
lab=#net6}
N 940 -920 950 -920 {
lab=#net6}
N 810 -940 930 -940 {
lab=#net11}
N 930 -940 930 -900 {
lab=#net11}
N 930 -900 950 -900 {
lab=#net11}
N 810 -920 920 -920 {
lab=#net12}
N 920 -920 920 -880 {
lab=#net12}
N 920 -880 950 -880 {
lab=#net12}
N 810 -900 910 -900 {
lab=#net13}
N 910 -900 910 -820 {
lab=#net13}
N 910 -820 950 -820 {
lab=#net13}
N 900 -800 950 -800 {
lab=#net14}
N 900 -880 900 -800 {
lab=#net14}
N 810 -880 900 -880 {
lab=#net14}
N 810 -860 890 -860 {
lab=#net15}
N 890 -860 890 -780 {
lab=#net15}
N 890 -780 950 -780 {
lab=#net15}
N 880 -760 950 -760 {
lab=#net16}
N 880 -840 880 -760 {
lab=#net16}
N 810 -840 880 -840 {
lab=#net16}
N 1250 -1200 1320 -1200 {
lab=Vinj}
N 1320 -1200 1320 -1060 {
lab=Vinj}
N 1250 -1060 1320 -1060 {
lab=Vinj}
N 1320 -1060 1320 -940 {
lab=Vinj}
N 1250 -940 1320 -940 {
lab=Vinj}
N 1250 -820 1320 -820 {
lab=Vinj}
N 1320 -940 1320 -820 {
lab=Vinj}
N 1250 -740 1350 -740 {
lab=GND}
N 1350 -860 1350 -740 {
lab=GND}
N 1250 -860 1350 -860 {
lab=GND}
N 1250 -980 1350 -980 {
lab=GND}
N 1250 -1120 1350 -1120 {
lab=GND}
N 1350 -980 1350 -860 {
lab=GND}
N 1350 -1120 1350 -980 {
lab=GND}
N 1250 -1180 1400 -1180 {
lab=Out}
N 1400 -1180 1400 -800 {
lab=Out}
N 1250 -800 1400 -800 {
lab=Out}
N 1250 -920 1400 -920 {
lab=Out}
N 1250 -1040 1400 -1040 {
lab=Out}
N 1250 -1160 1270 -1160 {
lab=#net17}
N 1320 -1260 1320 -1200 {
lab=Vinj}
N 1250 -1140 1270 -1140 {
lab=#net18}
N 1270 -1140 1270 -1020 {
lab=#net18}
N 1250 -1020 1270 -1020 {
lab=#net18}
N 1250 -1000 1270 -1000 {
lab=#net19}
N 1270 -1000 1270 -900 {
lab=#net19}
N 1250 -900 1270 -900 {
lab=#net19}
N 1250 -880 1270 -880 {
lab=#net20}
N 1270 -880 1270 -780 {
lab=#net20}
N 1250 -780 1270 -780 {
lab=#net20}
N 1250 -760 1270 -760 {
lab=#net21}
N 610 -800 610 -780 {
lab=GND}
N 610 -1140 700 -1140 {
lab=#net7}
N 610 -1120 700 -1120 {
lab=#net8}
N 610 -1100 700 -1100 {
lab=#net9}
N 610 -1080 700 -1080 {
lab=#net10}
N 610 -1060 700 -1060 {
lab=#net1}
N 610 -1040 700 -1040 {
lab=#net2}
N 610 -1020 700 -1020 {
lab=#net3}
N 610 -1000 700 -1000 {
lab=#net4}
N 610 -980 700 -980 {
lab=#net5}
N 610 -960 700 -960 {
lab=#net6}
N 610 -940 700 -940 {
lab=#net11}
N 610 -920 700 -920 {
lab=#net12}
N 610 -900 700 -900 {
lab=#net13}
N 610 -880 700 -880 {
lab=#net14}
N 610 -860 700 -860 {
lab=#net15}
N 610 -840 700 -840 {
lab=#net16}
N 610 -820 610 -800 {
lab=GND}
N 610 -1160 620 -1160 {
lab=Vinj}
N 620 -1210 620 -1160 {
lab=Vinj}
N 700 -1140 870 -1140 {
lab=#net7}
N 700 -1120 870 -1120 {
lab=#net8}
N 700 -1100 870 -1100 {
lab=#net9}
N 700 -1080 870 -1080 {
lab=#net10}
N 700 -1060 810 -1060 {
lab=#net1}
N 700 -1040 810 -1040 {
lab=#net2}
N 700 -1020 810 -1020 {
lab=#net3}
N 700 -1000 810 -1000 {
lab=#net4}
N 700 -980 810 -980 {
lab=#net5}
N 700 -960 810 -960 {
lab=#net6}
N 700 -940 810 -940 {
lab=#net11}
N 700 -920 810 -920 {
lab=#net12}
N 700 -900 810 -900 {
lab=#net13}
N 700 -880 810 -880 {
lab=#net14}
N 700 -860 810 -860 {
lab=#net15}
N 700 -840 810 -840 {
lab=#net16}
N 810 -480 870 -480 {
lab=#net22}
N 810 -460 870 -460 {
lab=#net23}
N 810 -440 870 -440 {
lab=#net24}
N 810 -420 870 -420 {
lab=#net25}
N 810 -400 870 -400 {
lab=#net26}
N 810 -380 870 -380 {
lab=#net27}
N 870 -620 870 -560 {
lab=#net28}
N 870 -620 950 -620 {
lab=#net28}
N 890 -600 950 -600 {
lab=#net29}
N 890 -600 890 -540 {
lab=#net29}
N 870 -540 890 -540 {
lab=#net29}
N 870 -520 910 -520 {
lab=#net30}
N 910 -580 910 -520 {
lab=#net30}
N 910 -580 950 -580 {
lab=#net30}
N 870 -500 930 -500 {
lab=#net31}
N 930 -560 930 -500 {
lab=#net31}
N 930 -560 950 -560 {
lab=#net31}
N 870 -480 950 -480 {
lab=#net22}
N 870 -460 950 -460 {
lab=#net23}
N 870 -440 950 -440 {
lab=#net24}
N 870 -420 950 -420 {
lab=#net25}
N 870 -400 950 -400 {
lab=#net26}
N 950 -400 950 -360 {
lab=#net26}
N 870 -380 940 -380 {
lab=#net27}
N 940 -380 940 -340 {
lab=#net27}
N 940 -340 950 -340 {
lab=#net27}
N 810 -360 930 -360 {
lab=#net32}
N 930 -360 930 -320 {
lab=#net32}
N 930 -320 950 -320 {
lab=#net32}
N 810 -340 920 -340 {
lab=#net33}
N 920 -340 920 -300 {
lab=#net33}
N 920 -300 950 -300 {
lab=#net33}
N 810 -320 910 -320 {
lab=#net34}
N 910 -320 910 -240 {
lab=#net34}
N 910 -240 950 -240 {
lab=#net34}
N 900 -220 950 -220 {
lab=#net35}
N 900 -300 900 -220 {
lab=#net35}
N 810 -300 900 -300 {
lab=#net35}
N 810 -280 890 -280 {
lab=#net36}
N 890 -280 890 -200 {
lab=#net36}
N 890 -200 950 -200 {
lab=#net36}
N 880 -180 950 -180 {
lab=#net37}
N 880 -260 880 -180 {
lab=#net37}
N 810 -260 880 -260 {
lab=#net37}
N 1250 -620 1320 -620 {
lab=Vinj}
N 1320 -620 1320 -480 {
lab=Vinj}
N 1250 -480 1320 -480 {
lab=Vinj}
N 1320 -480 1320 -360 {
lab=Vinj}
N 1250 -360 1320 -360 {
lab=Vinj}
N 1250 -240 1320 -240 {
lab=Vinj}
N 1320 -360 1320 -240 {
lab=Vinj}
N 1250 -160 1350 -160 {
lab=GND}
N 1350 -280 1350 -160 {
lab=GND}
N 1250 -280 1350 -280 {
lab=GND}
N 1250 -400 1350 -400 {
lab=GND}
N 1250 -540 1350 -540 {
lab=GND}
N 1350 -400 1350 -280 {
lab=GND}
N 1350 -540 1350 -400 {
lab=GND}
N 1250 -600 1400 -600 {
lab=Out}
N 1400 -600 1400 -220 {
lab=Out}
N 1250 -220 1400 -220 {
lab=Out}
N 1250 -340 1400 -340 {
lab=Out}
N 1250 -460 1400 -460 {
lab=Out}
N 1250 -580 1270 -580 {
lab=#net21}
N 1320 -680 1320 -620 {
lab=Vinj}
N 1250 -560 1270 -560 {
lab=#net38}
N 1270 -560 1270 -440 {
lab=#net38}
N 1250 -440 1270 -440 {
lab=#net38}
N 1250 -420 1270 -420 {
lab=#net39}
N 1270 -420 1270 -320 {
lab=#net39}
N 1250 -320 1270 -320 {
lab=#net39}
N 1250 -300 1270 -300 {
lab=#net40}
N 1270 -300 1270 -200 {
lab=#net40}
N 1250 -200 1270 -200 {
lab=#net40}
N 1250 -180 1270 -180 {
lab=GND}
N 1270 -180 1270 -160 {
lab=GND}
N 1350 -160 1350 -130 {
lab=GND}
N 610 -560 700 -560 {
lab=#net28}
N 610 -540 700 -540 {
lab=#net29}
N 610 -520 700 -520 {
lab=#net30}
N 610 -500 700 -500 {
lab=#net31}
N 610 -480 700 -480 {
lab=#net22}
N 610 -460 700 -460 {
lab=#net23}
N 610 -440 700 -440 {
lab=#net24}
N 610 -420 700 -420 {
lab=#net25}
N 610 -400 700 -400 {
lab=#net26}
N 610 -380 700 -380 {
lab=#net27}
N 610 -360 700 -360 {
lab=#net32}
N 610 -340 700 -340 {
lab=#net33}
N 610 -320 700 -320 {
lab=#net34}
N 610 -300 700 -300 {
lab=#net35}
N 610 -280 700 -280 {
lab=#net36}
N 610 -260 700 -260 {
lab=#net37}
N 610 -580 620 -580 {
lab=Vinj}
N 620 -630 620 -580 {
lab=Vinj}
N 700 -560 870 -560 {
lab=#net28}
N 700 -540 870 -540 {
lab=#net29}
N 700 -520 870 -520 {
lab=#net30}
N 700 -500 870 -500 {
lab=#net31}
N 700 -480 810 -480 {
lab=#net22}
N 700 -460 810 -460 {
lab=#net23}
N 700 -440 810 -440 {
lab=#net24}
N 700 -420 810 -420 {
lab=#net25}
N 700 -400 810 -400 {
lab=#net26}
N 700 -380 810 -380 {
lab=#net27}
N 700 -360 810 -360 {
lab=#net32}
N 700 -340 810 -340 {
lab=#net33}
N 700 -320 810 -320 {
lab=#net34}
N 700 -300 810 -300 {
lab=#net35}
N 700 -280 810 -280 {
lab=#net36}
N 700 -260 810 -260 {
lab=#net37}
N 810 -1660 870 -1660 {
lab=#net41}
N 810 -1640 870 -1640 {
lab=#net42}
N 810 -1620 870 -1620 {
lab=#net43}
N 810 -1600 870 -1600 {
lab=#net44}
N 810 -1580 870 -1580 {
lab=#net45}
N 810 -1560 870 -1560 {
lab=#net46}
N 870 -1800 870 -1740 {
lab=#net47}
N 870 -1800 950 -1800 {
lab=#net47}
N 890 -1780 950 -1780 {
lab=#net48}
N 890 -1780 890 -1720 {
lab=#net48}
N 870 -1720 890 -1720 {
lab=#net48}
N 870 -1700 910 -1700 {
lab=#net49}
N 910 -1760 910 -1700 {
lab=#net49}
N 910 -1760 950 -1760 {
lab=#net49}
N 870 -1680 930 -1680 {
lab=#net50}
N 930 -1740 930 -1680 {
lab=#net50}
N 930 -1740 950 -1740 {
lab=#net50}
N 870 -1660 950 -1660 {
lab=#net41}
N 870 -1640 950 -1640 {
lab=#net42}
N 870 -1620 950 -1620 {
lab=#net43}
N 870 -1600 950 -1600 {
lab=#net44}
N 870 -1580 950 -1580 {
lab=#net45}
N 950 -1580 950 -1540 {
lab=#net45}
N 870 -1560 940 -1560 {
lab=#net46}
N 940 -1560 940 -1520 {
lab=#net46}
N 940 -1520 950 -1520 {
lab=#net46}
N 810 -1540 930 -1540 {
lab=#net51}
N 930 -1540 930 -1500 {
lab=#net51}
N 930 -1500 950 -1500 {
lab=#net51}
N 810 -1520 920 -1520 {
lab=#net52}
N 920 -1520 920 -1480 {
lab=#net52}
N 920 -1480 950 -1480 {
lab=#net52}
N 810 -1500 910 -1500 {
lab=#net53}
N 910 -1500 910 -1420 {
lab=#net53}
N 910 -1420 950 -1420 {
lab=#net53}
N 900 -1400 950 -1400 {
lab=#net54}
N 900 -1480 900 -1400 {
lab=#net54}
N 810 -1480 900 -1480 {
lab=#net54}
N 810 -1460 890 -1460 {
lab=#net55}
N 890 -1460 890 -1380 {
lab=#net55}
N 890 -1380 950 -1380 {
lab=#net55}
N 880 -1360 950 -1360 {
lab=#net56}
N 880 -1440 880 -1360 {
lab=#net56}
N 810 -1440 880 -1440 {
lab=#net56}
N 1250 -1800 1320 -1800 {
lab=Vinj}
N 1320 -1800 1320 -1660 {
lab=Vinj}
N 1250 -1660 1320 -1660 {
lab=Vinj}
N 1320 -1660 1320 -1540 {
lab=Vinj}
N 1250 -1540 1320 -1540 {
lab=Vinj}
N 1250 -1420 1320 -1420 {
lab=Vinj}
N 1320 -1540 1320 -1420 {
lab=Vinj}
N 1250 -1340 1350 -1340 {
lab=GND}
N 1350 -1460 1350 -1340 {
lab=GND}
N 1250 -1460 1350 -1460 {
lab=GND}
N 1250 -1580 1350 -1580 {
lab=GND}
N 1250 -1720 1350 -1720 {
lab=GND}
N 1350 -1580 1350 -1460 {
lab=GND}
N 1350 -1720 1350 -1580 {
lab=GND}
N 1250 -1780 1400 -1780 {
lab=Out}
N 1400 -1780 1400 -1400 {
lab=Out}
N 1250 -1400 1400 -1400 {
lab=Out}
N 1250 -1520 1400 -1520 {
lab=Out}
N 1250 -1640 1400 -1640 {
lab=Out}
N 1250 -1760 1270 -1760 {
lab=#net57}
N 1320 -1860 1320 -1800 {
lab=Vinj}
N 1250 -1740 1270 -1740 {
lab=#net58}
N 1270 -1740 1270 -1620 {
lab=#net58}
N 1250 -1620 1270 -1620 {
lab=#net58}
N 1250 -1600 1270 -1600 {
lab=#net59}
N 1270 -1600 1270 -1500 {
lab=#net59}
N 1250 -1500 1270 -1500 {
lab=#net59}
N 1250 -1480 1270 -1480 {
lab=#net60}
N 1270 -1480 1270 -1380 {
lab=#net60}
N 1250 -1380 1270 -1380 {
lab=#net60}
N 1250 -1360 1270 -1360 {
lab=#net17}
N 1350 -1340 1350 -1310 {
lab=GND}
N 610 -1400 610 -1380 {
lab=GND}
N 610 -1740 700 -1740 {
lab=#net47}
N 610 -1720 700 -1720 {
lab=#net48}
N 610 -1700 700 -1700 {
lab=#net49}
N 610 -1680 700 -1680 {
lab=#net50}
N 610 -1660 700 -1660 {
lab=#net41}
N 610 -1640 700 -1640 {
lab=#net42}
N 610 -1620 700 -1620 {
lab=#net43}
N 610 -1600 700 -1600 {
lab=#net44}
N 610 -1580 700 -1580 {
lab=#net45}
N 610 -1560 700 -1560 {
lab=#net46}
N 610 -1540 700 -1540 {
lab=#net51}
N 610 -1520 700 -1520 {
lab=#net52}
N 610 -1500 700 -1500 {
lab=#net53}
N 610 -1480 700 -1480 {
lab=#net54}
N 610 -1460 700 -1460 {
lab=#net55}
N 610 -1440 700 -1440 {
lab=#net56}
N 610 -1420 610 -1400 {
lab=GND}
N 610 -1760 620 -1760 {
lab=Vinj}
N 620 -1810 620 -1760 {
lab=Vinj}
N 700 -1740 870 -1740 {
lab=#net47}
N 700 -1720 870 -1720 {
lab=#net48}
N 700 -1700 870 -1700 {
lab=#net49}
N 700 -1680 870 -1680 {
lab=#net50}
N 700 -1660 810 -1660 {
lab=#net41}
N 700 -1640 810 -1640 {
lab=#net42}
N 700 -1620 810 -1620 {
lab=#net43}
N 700 -1600 810 -1600 {
lab=#net44}
N 700 -1580 810 -1580 {
lab=#net45}
N 700 -1560 810 -1560 {
lab=#net46}
N 700 -1540 810 -1540 {
lab=#net51}
N 700 -1520 810 -1520 {
lab=#net52}
N 700 -1500 810 -1500 {
lab=#net53}
N 700 -1480 810 -1480 {
lab=#net54}
N 700 -1460 810 -1460 {
lab=#net55}
N 700 -1440 810 -1440 {
lab=#net56}
N 810 -2320 870 -2320 {
lab=#net61}
N 810 -2300 870 -2300 {
lab=#net62}
N 810 -2280 870 -2280 {
lab=#net63}
N 810 -2260 870 -2260 {
lab=#net64}
N 810 -2240 870 -2240 {
lab=#net65}
N 810 -2220 870 -2220 {
lab=#net66}
N 870 -2460 870 -2400 {
lab=#net67}
N 870 -2460 950 -2460 {
lab=#net67}
N 890 -2440 950 -2440 {
lab=#net68}
N 890 -2440 890 -2380 {
lab=#net68}
N 870 -2380 890 -2380 {
lab=#net68}
N 870 -2360 910 -2360 {
lab=#net69}
N 910 -2420 910 -2360 {
lab=#net69}
N 910 -2420 950 -2420 {
lab=#net69}
N 870 -2340 930 -2340 {
lab=#net70}
N 930 -2400 930 -2340 {
lab=#net70}
N 930 -2400 950 -2400 {
lab=#net70}
N 870 -2320 950 -2320 {
lab=#net61}
N 870 -2300 950 -2300 {
lab=#net62}
N 870 -2280 950 -2280 {
lab=#net63}
N 870 -2260 950 -2260 {
lab=#net64}
N 870 -2240 950 -2240 {
lab=#net65}
N 950 -2240 950 -2200 {
lab=#net65}
N 870 -2220 940 -2220 {
lab=#net66}
N 940 -2220 940 -2180 {
lab=#net66}
N 940 -2180 950 -2180 {
lab=#net66}
N 810 -2200 930 -2200 {
lab=#net71}
N 930 -2200 930 -2160 {
lab=#net71}
N 930 -2160 950 -2160 {
lab=#net71}
N 810 -2180 920 -2180 {
lab=#net72}
N 920 -2180 920 -2140 {
lab=#net72}
N 920 -2140 950 -2140 {
lab=#net72}
N 810 -2160 910 -2160 {
lab=#net73}
N 910 -2160 910 -2080 {
lab=#net73}
N 910 -2080 950 -2080 {
lab=#net73}
N 900 -2060 950 -2060 {
lab=#net74}
N 900 -2140 900 -2060 {
lab=#net74}
N 810 -2140 900 -2140 {
lab=#net74}
N 810 -2120 890 -2120 {
lab=#net75}
N 890 -2120 890 -2040 {
lab=#net75}
N 890 -2040 950 -2040 {
lab=#net75}
N 880 -2020 950 -2020 {
lab=#net76}
N 880 -2100 880 -2020 {
lab=#net76}
N 810 -2100 880 -2100 {
lab=#net76}
N 1250 -2460 1320 -2460 {
lab=Vinj}
N 1320 -2460 1320 -2320 {
lab=Vinj}
N 1250 -2320 1320 -2320 {
lab=Vinj}
N 1320 -2320 1320 -2200 {
lab=Vinj}
N 1250 -2200 1320 -2200 {
lab=Vinj}
N 1250 -2080 1320 -2080 {
lab=Vinj}
N 1320 -2200 1320 -2080 {
lab=Vinj}
N 1250 -2000 1350 -2000 {
lab=GND}
N 1350 -2120 1350 -2000 {
lab=GND}
N 1250 -2120 1350 -2120 {
lab=GND}
N 1250 -2240 1350 -2240 {
lab=GND}
N 1250 -2380 1350 -2380 {
lab=GND}
N 1350 -2240 1350 -2120 {
lab=GND}
N 1350 -2380 1350 -2240 {
lab=GND}
N 1250 -2440 1400 -2440 {
lab=Out}
N 1400 -2440 1400 -2060 {
lab=Out}
N 1250 -2060 1400 -2060 {
lab=Out}
N 1250 -2180 1400 -2180 {
lab=Out}
N 1250 -2300 1400 -2300 {
lab=Out}
N 1250 -2420 1270 -2420 {
lab=Vinj}
N 1270 -2460 1270 -2420 {
lab=Vinj}
N 1320 -2520 1320 -2460 {
lab=Vinj}
N 1250 -2400 1270 -2400 {
lab=#net77}
N 1270 -2400 1270 -2280 {
lab=#net77}
N 1250 -2280 1270 -2280 {
lab=#net77}
N 1250 -2260 1270 -2260 {
lab=#net78}
N 1270 -2260 1270 -2160 {
lab=#net78}
N 1250 -2160 1270 -2160 {
lab=#net78}
N 1250 -2140 1270 -2140 {
lab=#net79}
N 1270 -2140 1270 -2040 {
lab=#net79}
N 1250 -2040 1270 -2040 {
lab=#net79}
N 1250 -2020 1270 -2020 {
lab=#net57}
N 1350 -2000 1350 -1970 {
lab=GND}
N 610 -2060 610 -2040 {
lab=GND}
N 610 -2400 700 -2400 {
lab=#net67}
N 610 -2380 700 -2380 {
lab=#net68}
N 610 -2360 700 -2360 {
lab=#net69}
N 610 -2340 700 -2340 {
lab=#net70}
N 610 -2320 700 -2320 {
lab=#net61}
N 610 -2300 700 -2300 {
lab=#net62}
N 610 -2280 700 -2280 {
lab=#net63}
N 610 -2260 700 -2260 {
lab=#net64}
N 610 -2240 700 -2240 {
lab=#net65}
N 610 -2220 700 -2220 {
lab=#net66}
N 610 -2200 700 -2200 {
lab=#net71}
N 610 -2180 700 -2180 {
lab=#net72}
N 610 -2160 700 -2160 {
lab=#net73}
N 610 -2140 700 -2140 {
lab=#net74}
N 610 -2120 700 -2120 {
lab=#net75}
N 610 -2100 700 -2100 {
lab=#net76}
N 610 -2080 610 -2060 {
lab=GND}
N 610 -2420 620 -2420 {
lab=Vinj}
N 620 -2470 620 -2420 {
lab=Vinj}
N 700 -2400 870 -2400 {
lab=#net67}
N 700 -2380 870 -2380 {
lab=#net68}
N 700 -2360 870 -2360 {
lab=#net69}
N 700 -2340 870 -2340 {
lab=#net70}
N 700 -2320 810 -2320 {
lab=#net61}
N 700 -2300 810 -2300 {
lab=#net62}
N 700 -2280 810 -2280 {
lab=#net63}
N 700 -2260 810 -2260 {
lab=#net64}
N 700 -2240 810 -2240 {
lab=#net65}
N 700 -2220 810 -2220 {
lab=#net66}
N 700 -2200 810 -2200 {
lab=#net71}
N 700 -2180 810 -2180 {
lab=#net72}
N 700 -2160 810 -2160 {
lab=#net73}
N 700 -2140 810 -2140 {
lab=#net74}
N 700 -2120 810 -2120 {
lab=#net75}
N 700 -2100 810 -2100 {
lab=#net76}
N 1400 -800 1400 -600 {
lab=Out}
N 1400 -1400 1400 -1180 {
lab=Out}
N 1400 -1280 1560 -1280 {
lab=Out}
N 1400 -2060 1400 -1780 {
lab=Out}
N 1350 -740 1350 -540 {
lab=GND}
N 610 -240 610 -210 {
lab=GND}
N 1350 -1310 1350 -1120 {
lab=GND}
N 1350 -1970 1350 -1720 {
lab=GND}
N 1270 -2020 1270 -1760 {
lab=#net57}
N 1270 -1360 1270 -1160 {
lab=#net17}
N 1270 -760 1270 -580 {
lab=#net21}
N 1320 -2080 1320 -1860 {
lab=Vinj}
N 1320 -1420 1320 -1260 {
lab=Vinj}
N 1320 -820 1320 -680 {
lab=Vinj}
N -30 -1310 120 -1310 {
lab=#net80}
N 120 -2380 120 -1310 {
lab=#net80}
N -30 -1290 160 -1290 {
lab=#net81}
N 160 -1720 160 -1290 {
lab=#net81}
N -30 -1270 160 -1270 {
lab=#net82}
N 160 -1270 160 -1120 {
lab=#net82}
N -30 -1250 120 -1250 {
lab=#net83}
N 120 -1250 120 -540 {
lab=#net83}
N -380 -1290 -330 -1290 {
lab=In5}
N -380 -1310 -330 -1310 {
lab=In6}
N -380 -1330 -330 -1330 {
lab=ENABLE}
N 120 -540 160 -540 {
lab=#net83}
N 160 -1120 310 -1120 {
lab=#net82}
N 250 -1080 310 -1080 {
lab=In1}
N 250 -1100 310 -1100 {
lab=In2}
N 250 -1160 310 -1160 {
lab=In3}
N 250 -1140 310 -1140 {
lab=In4}
N 120 -2380 160 -2380 {
lab=#net80}
N 160 -1720 310 -1720 {
lab=#net81}
N 250 -1680 310 -1680 {
lab=In1}
N 250 -1700 310 -1700 {
lab=In2}
N 250 -1760 310 -1760 {
lab=In3}
N 250 -1740 310 -1740 {
lab=In4}
N 160 -2380 310 -2380 {
lab=#net80}
N 250 -2340 310 -2340 {
lab=In1}
N 250 -2360 310 -2360 {
lab=In2}
N 250 -2420 310 -2420 {
lab=In3}
N 250 -2400 310 -2400 {
lab=In4}
N 160 -540 310 -540 {
lab=#net83}
N 250 -500 310 -500 {
lab=In1}
N 250 -520 310 -520 {
lab=In2}
N 250 -580 310 -580 {
lab=In3}
N 250 -560 310 -560 {
lab=In4}
N -30 -1330 0 -1330 {
lab=Vinj}
N -30 -1230 -0 -1230 {
lab=GND}
C {RDAC_4bit_cell.sym} 1100 -1160 0 0 {name=x1}
C {RDAC_4bit_cell.sym} 1100 -1020 0 0 {name=x2}
C {RDAC_4bit_cell.sym} 1100 -900 0 0 {name=x3}
C {RDAC_4bit_cell.sym} 1100 -780 0 0 {name=x4}
C {lab_pin.sym} 620 -1210 2 0 {name=p9 sig_type=std_logic lab=Vinj}
C {sky130_cells/RDAC/Design/sky130_hilas_Vinj_Decode_4to16.sym} 450 -1000 0 0 {name=x5}
C {RDAC_4bit_cell.sym} 1100 -580 0 0 {name=x6}
C {RDAC_4bit_cell.sym} 1100 -440 0 0 {name=x7}
C {RDAC_4bit_cell.sym} 1100 -320 0 0 {name=x8}
C {RDAC_4bit_cell.sym} 1100 -200 0 0 {name=x9}
C {lab_pin.sym} 620 -630 2 0 {name=p5 sig_type=std_logic lab=Vinj}
C {sky130_cells/RDAC/Design/sky130_hilas_Vinj_Decode_4to16.sym} 450 -420 0 0 {name=x10}
C {RDAC_4bit_cell.sym} 1100 -1760 0 0 {name=x11}
C {RDAC_4bit_cell.sym} 1100 -1620 0 0 {name=x12}
C {RDAC_4bit_cell.sym} 1100 -1500 0 0 {name=x13}
C {RDAC_4bit_cell.sym} 1100 -1380 0 0 {name=x14}
C {lab_pin.sym} 620 -1810 2 0 {name=p47 sig_type=std_logic lab=Vinj}
C {sky130_cells/RDAC/Design/sky130_hilas_Vinj_Decode_4to16.sym} 450 -1600 0 0 {name=x15}
C {RDAC_4bit_cell.sym} 1100 -2420 0 0 {name=x16}
C {RDAC_4bit_cell.sym} 1100 -2280 0 0 {name=x17}
C {RDAC_4bit_cell.sym} 1100 -2160 0 0 {name=x18}
C {RDAC_4bit_cell.sym} 1100 -2040 0 0 {name=x19}
C {lab_pin.sym} 620 -2470 2 0 {name=p68 sig_type=std_logic lab=Vinj}
C {sky130_cells/RDAC/Design/sky130_hilas_Vinj_Decode_4to16.sym} 450 -2260 0 0 {name=x20}
C {opin.sym} 1560 -1280 0 0 {name=p1 lab=Out}
C {iopin.sym} 1350 -130 0 0 {name=p14 lab=GND}
C {lab_pin.sym} 1320 -2520 2 0 {name=p10 sig_type=std_logic lab=Vinj}
C {lab_pin.sym} 610 -780 2 0 {name=p11 sig_type=std_logic lab=GND}
C {lab_pin.sym} 610 -210 2 0 {name=p15 sig_type=std_logic lab=GND}
C {lab_pin.sym} 610 -1380 2 0 {name=p2 sig_type=std_logic lab=GND}
C {lab_pin.sym} 0 -1230 2 0 {name=p3 sig_type=std_logic lab=GND}
C {lab_pin.sym} 610 -2040 2 0 {name=p4 sig_type=std_logic lab=GND}
C {lab_pin.sym} 0 -1330 2 0 {name=p6 sig_type=std_logic lab=Vinj}
C {ipin.sym} -240 -1180 0 0 {name=p7 lab=In1}
C {ipin.sym} -240 -1150 0 0 {name=p8 lab=In2}
C {ipin.sym} -240 -1120 0 0 {name=p16 lab=In3}
C {ipin.sym} -240 -1090 0 0 {name=p17 lab=In4}
C {ipin.sym} -380 -1290 0 0 {name=p18 lab=In5}
C {ipin.sym} -380 -1310 0 0 {name=p19 lab=In6}
C {ipin.sym} -380 -1330 0 0 {name=p40 lab=ENABLE}
C {lab_pin.sym} 250 -1160 0 0 {name=p23 sig_type=std_logic lab=In3}
C {lab_pin.sym} 250 -1140 0 0 {name=p24 sig_type=std_logic lab=In4}
C {lab_pin.sym} 250 -1080 0 0 {name=p25 sig_type=std_logic lab=In1}
C {lab_pin.sym} 250 -1100 0 0 {name=p26 sig_type=std_logic lab=In2}
C {iopin.sym} 320 -2540 2 0 {name=p12 lab=Vinj}
C {lab_pin.sym} 250 -1760 0 0 {name=p27 sig_type=std_logic lab=In3}
C {lab_pin.sym} 250 -1740 0 0 {name=p28 sig_type=std_logic lab=In4}
C {lab_pin.sym} 250 -1680 0 0 {name=p29 sig_type=std_logic lab=In1}
C {lab_pin.sym} 250 -1700 0 0 {name=p30 sig_type=std_logic lab=In2}
C {lab_pin.sym} 250 -2420 0 0 {name=p31 sig_type=std_logic lab=In3}
C {lab_pin.sym} 250 -2400 0 0 {name=p32 sig_type=std_logic lab=In4}
C {lab_pin.sym} 250 -2340 0 0 {name=p33 sig_type=std_logic lab=In1}
C {lab_pin.sym} 250 -2360 0 0 {name=p34 sig_type=std_logic lab=In2}
C {lab_pin.sym} 250 -580 0 0 {name=p13 sig_type=std_logic lab=In3}
C {lab_pin.sym} 250 -560 0 0 {name=p20 sig_type=std_logic lab=In4}
C {lab_pin.sym} 250 -520 0 0 {name=p21 sig_type=std_logic lab=In2}
C {lab_pin.sym} 250 -500 0 0 {name=p22 sig_type=std_logic lab=In1}
C {sky130_cells/RDAC/Design/sky130_hilas_VinjDecode2to4.sym} -180 -1280 0 0 {name=x21}
