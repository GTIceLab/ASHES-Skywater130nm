v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 1190 -680 1190 -660 {
lab=GND}
N 1190 -700 1190 -680 {
lab=GND}
N 1190 -1040 1200 -1040 {
lab=Vinj}
N 1200 -1090 1200 -1040 {
lab=Vinj}
N 1190 -440 1280 -440 {
lab=#net1}
N 1190 -420 1280 -420 {
lab=#net2}
N 1190 -400 1280 -400 {
lab=#net3}
N 1190 -380 1280 -380 {
lab=#net4}
N 1190 -360 1280 -360 {
lab=#net5}
N 1190 -340 1280 -340 {
lab=#net6}
N 1190 -320 1280 -320 {
lab=#net7}
N 1190 -300 1280 -300 {
lab=#net8}
N 1190 -280 1280 -280 {
lab=#net9}
N 1190 -260 1280 -260 {
lab=#net10}
N 1190 -240 1280 -240 {
lab=#net11}
N 1190 -220 1280 -220 {
lab=#net12}
N 1190 -200 1280 -200 {
lab=#net13}
N 1190 -180 1280 -180 {
lab=#net14}
N 1190 -160 1280 -160 {
lab=#net15}
N 1190 -140 1280 -140 {
lab=#net16}
N 1190 -460 1200 -460 {
lab=Vinj}
N 1200 -510 1200 -460 {
lab=Vinj}
N 1190 -1280 1190 -1260 {
lab=GND}
N 1190 -1300 1190 -1280 {
lab=GND}
N 1190 -1640 1200 -1640 {
lab=Vinj}
N 1200 -1690 1200 -1640 {
lab=Vinj}
N 1190 -1940 1190 -1920 {
lab=GND}
N 1190 -1960 1190 -1940 {
lab=GND}
N 1190 -2300 1200 -2300 {
lab=Vinj}
N 1200 -2350 1200 -2300 {
lab=Vinj}
N 1190 -120 1190 -90 {
lab=GND}
N 550 -1190 700 -1190 {
lab=#net17}
N 700 -2260 700 -1190 {
lab=#net17}
N 550 -1170 740 -1170 {
lab=#net18}
N 740 -1600 740 -1170 {
lab=#net18}
N 550 -1150 740 -1150 {
lab=#net19}
N 740 -1150 740 -1000 {
lab=#net19}
N 550 -1130 700 -1130 {
lab=#net20}
N 700 -1130 700 -420 {
lab=#net20}
N 360 -1100 360 -1080 {
lab=GND}
N 200 -1170 250 -1170 {
lab=In1}
N 200 -1150 250 -1150 {
lab=In2}
N 200 -1130 250 -1130 {
lab=ENABLE}
N 220 -1190 250 -1190 {
lab=Vinj}
N 220 -1240 220 -1190 {
lab=Vinj}
N 700 -420 740 -420 {
lab=#net20}
N 740 -1000 890 -1000 {
lab=#net19}
N 830 -960 890 -960 {
lab=In3}
N 830 -980 890 -980 {
lab=In4}
N 830 -1040 890 -1040 {
lab=In5}
N 830 -1020 890 -1020 {
lab=In6}
N 700 -2260 740 -2260 {
lab=#net17}
N 740 -1600 890 -1600 {
lab=#net18}
N 830 -1560 890 -1560 {
lab=In3}
N 830 -1580 890 -1580 {
lab=In4}
N 830 -1640 890 -1640 {
lab=In5}
N 830 -1620 890 -1620 {
lab=In6}
N 740 -2260 890 -2260 {
lab=#net17}
N 830 -2220 890 -2220 {
lab=In3}
N 830 -2240 890 -2240 {
lab=In4}
N 830 -2300 890 -2300 {
lab=In5}
N 830 -2280 890 -2280 {
lab=In6}
N 740 -420 890 -420 {
lab=#net20}
N 830 -380 890 -380 {
lab=In3}
N 830 -400 890 -400 {
lab=In4}
N 830 -460 890 -460 {
lab=In5}
N 830 -440 890 -440 {
lab=In6}
N 1190 -2280 1280 -2280 {
lab=Vout0}
N 1190 -2260 1280 -2260 {
lab=Vout1}
N 1190 -2240 1280 -2240 {
lab=Vout2}
N 1190 -2220 1280 -2220 {
lab=Vout3}
N 1190 -2200 1280 -2200 {
lab=Vout4}
N 1190 -2180 1280 -2180 {
lab=Vout5}
N 1190 -2160 1280 -2160 {
lab=Vout6}
N 1190 -2140 1280 -2140 {
lab=Vout7}
N 1190 -2120 1280 -2120 {
lab=Vout8}
N 1190 -2100 1280 -2100 {
lab=Vout9}
N 1190 -2080 1280 -2080 {
lab=Vout10}
N 1190 -2060 1280 -2060 {
lab=Vout11}
N 1190 -2040 1280 -2040 {
lab=Vout12}
N 1190 -2020 1280 -2020 {
lab=Vout13}
N 1190 -2000 1280 -2000 {
lab=Vout14}
N 1190 -1980 1280 -1980 {
lab=Vout15}
N 1190 -1020 1280 -1020 {
lab=Vout0_3}
N 1190 -1000 1280 -1000 {
lab=Vout1_3}
N 1190 -980 1280 -980 {
lab=Vout2_3}
N 1190 -960 1280 -960 {
lab=Vout3_3}
N 1190 -940 1280 -940 {
lab=Vout4_3}
N 1190 -920 1280 -920 {
lab=Vout5_3}
N 1190 -900 1280 -900 {
lab=Vout6_3}
N 1190 -880 1280 -880 {
lab=Vout7_3}
N 1190 -860 1280 -860 {
lab=Vout8_3}
N 1190 -840 1280 -840 {
lab=Vout9_3}
N 1190 -820 1280 -820 {
lab=Vout10_3}
N 1190 -800 1280 -800 {
lab=Vout11_3}
N 1190 -780 1280 -780 {
lab=Vout12_3}
N 1190 -760 1280 -760 {
lab=Vout13_3}
N 1190 -740 1280 -740 {
lab=Vout14_3}
N 1190 -720 1280 -720 {
lab=Vout15_3}
C {lab_pin.sym} 1200 -1090 2 0 {name=p9 sig_type=std_logic lab=Vinj}
C {sky130_cells/RDAC/Design/sky130_hilas_Vinj_Decode_4to16.sym} 1030 -880 0 0 {name=x5}
C {lab_pin.sym} 1200 -510 2 0 {name=p5 sig_type=std_logic lab=Vinj}
C {sky130_cells/RDAC/Design/sky130_hilas_Vinj_Decode_4to16.sym} 1030 -300 0 0 {name=x10}
C {lab_pin.sym} 1200 -1690 2 0 {name=p47 sig_type=std_logic lab=Vinj}
C {sky130_cells/RDAC/Design/sky130_hilas_Vinj_Decode_4to16.sym} 1030 -1480 0 0 {name=x15}
C {lab_pin.sym} 1200 -2350 2 0 {name=p68 sig_type=std_logic lab=Vinj}
C {sky130_cells/RDAC/Design/sky130_hilas_Vinj_Decode_4to16.sym} 1030 -2140 0 0 {name=x20}
C {lab_pin.sym} 1190 -660 2 0 {name=p11 sig_type=std_logic lab=GND}
C {lab_pin.sym} 1190 -90 2 0 {name=p15 sig_type=std_logic lab=GND}
C {sky130_cells/RDAC/Design/sky130_hilas_VinjDecode2to4.sym} 400 -1160 0 0 {name=x21}
C {lab_pin.sym} 1190 -1260 2 0 {name=p2 sig_type=std_logic lab=GND}
C {lab_pin.sym} 360 -1080 2 0 {name=p3 sig_type=std_logic lab=GND}
C {lab_pin.sym} 1190 -1920 2 0 {name=p4 sig_type=std_logic lab=GND}
C {lab_pin.sym} 220 -1240 2 0 {name=p6 sig_type=std_logic lab=Vinj}
C {ipin.sym} 200 -1170 0 0 {name=p7 lab=In1}
C {ipin.sym} 200 -1150 0 0 {name=p8 lab=In2}
C {ipin.sym} 340 -1010 0 0 {name=p16 lab=In3}
C {ipin.sym} 340 -980 0 0 {name=p17 lab=In4}
C {ipin.sym} 340 -950 0 0 {name=p18 lab=In5}
C {ipin.sym} 340 -920 0 0 {name=p19 lab=In6}
C {ipin.sym} 200 -1130 0 0 {name=p40 lab=ENABLE}
C {lab_pin.sym} 830 -960 0 0 {name=p23 sig_type=std_logic lab=In3}
C {lab_pin.sym} 830 -980 0 0 {name=p24 sig_type=std_logic lab=In4}
C {lab_pin.sym} 830 -1040 0 0 {name=p25 sig_type=std_logic lab=In5}
C {lab_pin.sym} 830 -1020 0 0 {name=p26 sig_type=std_logic lab=In6}
C {iopin.sym} 900 -2420 2 0 {name=p12 lab=Vinj}
C {lab_pin.sym} 830 -1560 0 0 {name=p27 sig_type=std_logic lab=In3}
C {lab_pin.sym} 830 -1580 0 0 {name=p28 sig_type=std_logic lab=In4}
C {lab_pin.sym} 830 -1640 0 0 {name=p29 sig_type=std_logic lab=In5}
C {lab_pin.sym} 830 -1620 0 0 {name=p30 sig_type=std_logic lab=In6}
C {lab_pin.sym} 830 -2220 0 0 {name=p31 sig_type=std_logic lab=In3}
C {lab_pin.sym} 830 -2240 0 0 {name=p32 sig_type=std_logic lab=In4}
C {lab_pin.sym} 830 -2300 0 0 {name=p33 sig_type=std_logic lab=In5}
C {lab_pin.sym} 830 -2280 0 0 {name=p34 sig_type=std_logic lab=In6}
C {lab_pin.sym} 830 -380 0 0 {name=p13 sig_type=std_logic lab=In3}
C {lab_pin.sym} 830 -400 0 0 {name=p20 sig_type=std_logic lab=In4}
C {lab_pin.sym} 830 -460 0 0 {name=p21 sig_type=std_logic lab=In5}
C {lab_pin.sym} 830 -440 0 0 {name=p22 sig_type=std_logic lab=In6}
C {devices/code.sym} 1740 -2290 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval( @value )"
value="
** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice tt

"
spice_ignore=false}
C {lab_pin.sym} 1280 -2280 2 0 {name=p10 sig_type=std_logic lab=Vout0}
C {lab_pin.sym} 1280 -2260 2 0 {name=p14 sig_type=std_logic lab=Vout1}
C {lab_pin.sym} 1280 -2240 2 0 {name=p1 sig_type=std_logic lab=Vout2}
C {lab_pin.sym} 1280 -2220 2 0 {name=p35 sig_type=std_logic lab=Vout3}
C {lab_pin.sym} 1280 -2200 2 0 {name=p36 sig_type=std_logic lab=Vout4
}
C {lab_pin.sym} 1280 -2180 2 0 {name=p37 sig_type=std_logic lab=Vout5}
C {lab_pin.sym} 1280 -2160 2 0 {name=p38 sig_type=std_logic lab=Vout6}
C {lab_pin.sym} 1280 -2140 2 0 {name=p39 sig_type=std_logic lab=Vout7}
C {lab_pin.sym} 1280 -2120 2 0 {name=p41 sig_type=std_logic lab=Vout8}
C {lab_pin.sym} 1280 -2100 2 0 {name=p42 sig_type=std_logic lab=Vout9}
C {lab_pin.sym} 1280 -2080 2 0 {name=p43 sig_type=std_logic lab=Vout10}
C {lab_pin.sym} 1280 -2060 2 0 {name=p44 sig_type=std_logic lab=Vout11}
C {lab_pin.sym} 1280 -2040 2 0 {name=p45 sig_type=std_logic lab=Vout12}
C {lab_pin.sym} 1280 -2020 2 0 {name=p46 sig_type=std_logic lab=Vout13}
C {lab_pin.sym} 1280 -2000 2 0 {name=p48 sig_type=std_logic lab=Vout14}
C {lab_pin.sym} 1280 -1980 2 0 {name=p49 sig_type=std_logic lab=Vout15}
C {lab_pin.sym} 1280 -1020 2 0 {name=p50 sig_type=std_logic lab=Vout0_3}
C {lab_pin.sym} 1280 -1000 2 0 {name=p51 sig_type=std_logic lab=Vout1_3}
C {lab_pin.sym} 1280 -980 2 0 {name=p52 sig_type=std_logic lab=Vout2_3}
C {lab_pin.sym} 1280 -960 2 0 {name=p53 sig_type=std_logic lab=Vout3_3}
C {lab_pin.sym} 1280 -940 2 0 {name=p54 sig_type=std_logic lab=Vout4_3
}
C {lab_pin.sym} 1280 -920 2 0 {name=p55 sig_type=std_logic lab=Vout5_3}
C {lab_pin.sym} 1280 -900 2 0 {name=p56 sig_type=std_logic lab=Vout6_3}
C {lab_pin.sym} 1280 -880 2 0 {name=p57 sig_type=std_logic lab=Vout7_3}
C {lab_pin.sym} 1280 -860 2 0 {name=p58 sig_type=std_logic lab=Vout8_3}
C {lab_pin.sym} 1280 -840 2 0 {name=p59 sig_type=std_logic lab=Vout9_3}
C {lab_pin.sym} 1280 -820 2 0 {name=p60 sig_type=std_logic lab=Vout10_3}
C {lab_pin.sym} 1280 -800 2 0 {name=p61 sig_type=std_logic lab=Vout11_3}
C {lab_pin.sym} 1280 -780 2 0 {name=p62 sig_type=std_logic lab=Vout12_3}
C {lab_pin.sym} 1280 -760 2 0 {name=p63 sig_type=std_logic lab=Vout13_3}
C {lab_pin.sym} 1280 -740 2 0 {name=p64 sig_type=std_logic lab=Vout14_3}
C {lab_pin.sym} 1280 -720 2 0 {name=p65 sig_type=std_logic lab=Vout15_3}
C {code_shown.sym} 1490 -2130 0 0 {name=SPICE2 only_toplevel=false value="
.control
	tran 0.1n 8000n
	plot V(Vin1) V(Vin2) title 'Decoder Inputs'
	plot V(Vout0) V(Vout2) V(Vout4) V(Vout6) V(Vout8) V(Vout10) V(Vout12) V(Vout14) title 'Decoder Output'
	plot V(Vout1) V(Vout3) V(Vout5) V(Vout7) V(Vout9) V(Vout11) V(Vout13) V(Vout15) title 'Decoder Output'
	plot V(Vout0_3) V(Vout2_3) V(Vout4_3) V(Vout6_3) V(Vout8_3) V(Vout10_3) V(Vout12_3) V(Vout14_3) title 'Decoder Output'
	plot V(Vout1_3) V(Vout3_3) V(Vout5_3) V(Vout7_3) V(Vout9_3) V(Vout11_3) V(Vout13_3) V(Vout15_3) title 'Decoder Output'
.endc

.end"}
